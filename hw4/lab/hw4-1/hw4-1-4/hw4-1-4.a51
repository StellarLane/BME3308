ORG 0000H
LJMP START

ORG 0050H
	START:
	MOV 30H, #12H
	MOV 31H, #34H
	MOV 32H, #56H
	MOV 33H, #24H ; '$'
	
	
	MOV R0, #0030H
	MOV DPTR, #2000H
	LOOP1:
	MOV A, @R0
	CJNE A, #24H, LOOP2
	SJMP ENDEND
	LOOP2:
	MOVX @DPTR, A
	PUSH ACC
	MOV A, #00H
	MOVX A, @DPTR
	MOV R1, A
	POP ACC
	INC R0
	INC DPTR
	SJMP LOOP1
	ENDEND:
	SJMP $
	
END