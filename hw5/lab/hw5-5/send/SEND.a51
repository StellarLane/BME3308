ORG 0000H
LJMP START

ORG 0100H
	START:
	MOV 40H, #40
	MOV 41H, #41
	MOV 42H, #42
	ASTART:
	CLR EA
	MOV TMOD, #20H
	MOV TH1, #0F4H
	MOV PCON, #00H
	SETB TR1
	MOV SCON, #50H
	
	ALOOP1:
	MOV SBUF, #0E1H
	JNB TI, $
	CLR TI
	JNB RI, $
	CLR RI
	MOV A, SBUF
	XRL A, #0E2H
	JNZ ALOOP1
	ALOOP2:
	MOV R0, #40H
	MOV R7, #10H
	MOV R6, #00H
	
	ALOOP3:
	MOV SBUF, @R0
	MOV A, R6
	ADD A, @R0
	MOV R6, A
	INC R0
	JNB TI, $
	CLR TI
	MOV A, SBUF
	JNZ ALOOP2
	SJMP $
END