ORG 0000H
	LJMP START
ORG 0003H
	LJMP EINTO

ORG 0100H
	START:
	MOV R0, #30H
	MOV R2, #08H
	SETB EA
	SETB IT0
	SETB EX0
	
	LOOP:
	MOV DPTR, #000H
	MOVX @DPTR, A
	LCALL DELAY
	SJMP START
	
	DELAY:
	MOV R5, #050H
	DELAY_2:
	DJNZ R5, DELAY_2
	RET
	
ORG 0200H
	EINTO:
	MOVX A, @DPTR
	MOV @R0, A
	MOV P1, A
	INC DPTR
	INC R0
	DJNZ R2, NEXT
	CLR EA
	CLR EX0
	RETI
	
	NEXT:
	MOVX @DPTR, A
	RETI

END
	