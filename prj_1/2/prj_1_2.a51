ORG 0000H
LJMP INIT

ORG 0100H
	INIT:
	MOV SCON, #50H
	MOV TMOD, #20H
	MOV TH1, #0FDH
	MOV TL1, #0FDH
	SETB TR1
	SETB ES
	SETB EA
	MOV P1, #0H

	MAIN:
	CLR P1.0
	CLR P1.3
	SETB P1.2
	JNB RI, $
	CLR RI
	MOV A, SBUF
	CJNE A, #0ACH, CHECK
	LJMP MAIN
	
	CHECK:
	JC MAIN
	CLR P1.2
	SETB P1.3
	SETB P1.0
	LCALL DELAY
	LJMP MAIN
	
	DELAY:
	MOV R7, #20
	D1:
	MOV R6, #200
	DJNZ R6, $
	DJNZ R7, D1
	RET
END